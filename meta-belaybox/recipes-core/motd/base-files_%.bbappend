do_install:append () {
        rm ${D}${sysconfdir}/motd
}

