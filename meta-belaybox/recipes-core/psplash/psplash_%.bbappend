FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES:rpi = "file://pionixbox-img.h;outsuffix=raspberrypi"
