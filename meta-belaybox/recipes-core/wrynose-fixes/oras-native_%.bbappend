# meta-pionix-cloud v0.5.1 predates the UNPACKDIR split: its S = "${WORKDIR}"
# no longer points at the unpacked release tarball on wrynose.
S = "${UNPACKDIR}"
