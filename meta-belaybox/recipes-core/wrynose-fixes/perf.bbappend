EXTRA_OEMAKE:append = " NO_LIBTRACEEVENT=1 WERROR=0 EXTRA_CFLAGS='-Wno-error=discarded-qualifiers'"
