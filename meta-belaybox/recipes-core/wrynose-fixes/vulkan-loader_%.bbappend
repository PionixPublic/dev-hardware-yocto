BBCLASSEXTEND = "native nativesdk"
RRECOMMENDS:${PN} = ""
