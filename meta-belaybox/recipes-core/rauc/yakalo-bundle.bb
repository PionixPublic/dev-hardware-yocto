BUNDLE_IMAGE = "yakalo-image"
RAUC_BUNDLE_COMPATIBLE = "Belaybox"

require bundle-common.inc
