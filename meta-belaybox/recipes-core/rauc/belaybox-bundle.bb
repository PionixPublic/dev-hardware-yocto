BUNDLE_IMAGE = "belaybox-image"
RAUC_BUNDLE_COMPATIBLE = "${BELAYBOX_RAUC_COMPATIBLE}"
CLOUD_EDITION_ID ?= "com.pionix.belaybox"

FIRMWARE_VERSION ?= "3.0.0"
require bundle-common.inc
