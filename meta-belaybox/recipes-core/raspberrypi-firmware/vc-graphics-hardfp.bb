CONFLICTS = "vc-graphics"

VCDIR = "hardfp/opt/vc"
require belaybox-vc-graphics.inc

PR = "${INCPR}.0"
