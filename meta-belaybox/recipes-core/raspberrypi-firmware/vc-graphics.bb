CONFLICTS = "vc-graphics-hardfp"

VCDIR = "opt/vc"
require belaybox-vc-graphics.inc

PR = "${INCPR}.0"
